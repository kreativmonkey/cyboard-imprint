## dts/bindings/behaviors/zmk,behavior-battery-led.yaml
```yaml
description: Show the local battery charge on each half's RGB LEDs
compatible: "zmk,behavior-battery-led"
include: zero_param.yaml
```
